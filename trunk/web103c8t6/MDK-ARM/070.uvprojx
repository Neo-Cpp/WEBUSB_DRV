# Keil uVision project 070.uvprojx, settings and files
target 070 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 070 +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F103xB,CFG_TUSB_MCU=OPT_MCU_STM32F1
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Middlewares\ST\STM32_USB_Device_Library;..\Drivers\CMSIS\Device\ST\STM32F1xx\Include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group Application/User
    ../Src/: main.c usb_descriptors.c board.c stm32f103bluepill.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Middlewares/USB_Device_Library
    ../Src/: tusb.c
    ../Middlewares/ST/STM32_USB_Device_Library/common/: tusb_fifo.c
    ../Middlewares/ST/STM32_USB_Device_Library/device/: usbd.c usbd_control.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/msc/: msc_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/cdc/: cdc_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/dfu/: dfu_rt_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/hid/: hid_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/midi/: midi_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/usbtmc/: usbtmc_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/vendor/: vendor_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/class/net/: net_device.c
    ../Middlewares/ST/STM32_USB_Device_Library/portable/st/stm32_fsdev/: dcd_stm32_fsdev.c
software components: CMSIS:CORE 5.2.0
